## custom_defconfigs/aosp_defconfig
```kconfig
CONFIG_AOSP=y
CONFIG_DISABLE_LOCKSCREEN_USB_RESTRICTION=y
CONFIG_LOCALVERSION="-GoRhanHee-Kernel-AOSP"
```
